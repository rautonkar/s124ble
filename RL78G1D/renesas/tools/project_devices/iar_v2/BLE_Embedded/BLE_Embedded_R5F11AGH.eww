<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BLE_Emb_R5F11AGH\BLE_Emb_R5F11AGH.ewp</path>
  </project>
  <batchBuild/>
</workspace>


