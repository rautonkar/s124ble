# IAR project BLE_Emb_R5F11AGG.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenHugeHeapSize: 0
  General.GenDeviceSelect: R5F11AGG RL78 - R5F11AGG
  General.GenCodeModel: 1
  General.GenDataModel: 0
  General.GenStackSize: 800
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCDefines: CFG_FULLEMB; CFG_CON=1; CFG_EXMEM_NOT_PRESENT; CFG_BLECORE_10; CFG_PROFEMB; CFG_SECURITY_ON; CFG_RBLE; CFG_USE_EEL; CFG_FW_NAK; CONFIG_EMBEDDED; _USE_IAR_RL78; CFG_SAMPLE_BEACON; CLK_HOCO_8MHZ; CLK_SUB_XT1; USE_SAMPLE_PROFILE; noCFG_USE_PEAK; noUSE_FW_UPDATE_PROFILE; noCFG_PKTMON; _USE_R5F11AGG
  ICCRL78.CCDiagSuppress: Pa050, Go005, Pe177, Pe111, Pe167
  ICCRL78.CCIncludePath2: ..\..\..\..\..\src\driver\serial; ..\..\..\..\..\src\driver\wakeup; ..\..\..\..\..\src\driver\dataflash; ..\..\..\..\..\src\driver\dataflash\iar_v2; ..\..\..\..\..\src\driver\codeflash; ..\..\..\..\..\src\driver\codeflash\iar_v2; ..\..\..\..\..\src\driver\DTM2Wire; ..\..\..\..\..\src; ..\..\..\..\..\src\compiler; ..\..\..\..\..\src\arch\rl78; ..\..\..\..\..\src\arch\rl78\ll; ..\..\..\..\..\src\driver\led; ..\..\..\..\..\src\driver\plf; ..\..\..\..\..\src\driver\port; ..\..\..\..\..\src\driver\rf; ..\..\..\..\..\src\driver\uart; ..\..\..\..\..\src\driver\push_sw; ..\..\..\..\..\src\driver\pktmon; ..\..\..\..\..\..\bleip\src\common; ..\..\..\..\..\..\bleip\src\rwble; .\; ..\..\..\..\..\..\rble\src\include; ..\..\..\..\..\..\rBLE\src\sample_app; ..\..\..\..\..\..\rBLE\src\sample_profile
  OBJCOPY.OOCOutputFile: BLE_Emb_R5F11AGG.hex
  ILINK.IlinkOutputFile: BLE_Emb.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkIcfFile: ..\..\CONFIG\lnkr5f11agg.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCIncludePath2: ..\..\..\..\..\src\driver\serial; ..\..\..\..\..\src\driver\wakeup; ..\..\..\..\..\src\driver\dataflash\iar_v2; ..\..\..\..\..\src\driver\dataflash; ..\..\..\..\..\src\driver\codeflash\iar_v2; ..\..\..\..\..\src\driver\codeflash; ..\..\..\..\..\src\driver\DTM2Wire; ..\..\..\..\..\src; ..\..\..\..\..\src\compiler; ..\..\..\..\..\src\arch\rl78; ..\..\..\..\..\src\arch\rl78\ll; ..\..\..\..\..\src\driver\led; ..\..\..\..\..\src\driver\plf; ..\..\..\..\..\src\driver\port; ..\..\..\..\..\src\driver\rf; ..\..\..\..\..\src\driver\uart; ..\..\..\..\..\src\driver\push_sw; ..\..\..\..\..\src\driver\pktmon; ..\..\..\..\..\..\bleip\src\common; ..\..\..\..\..\..\bleip\src\rwble; .\; ..\..\..\..\..\..\rble\src\include; ..\..\..\..\..\..\rBLE\src\sample_app; ..\..\..\..\..\..\rBLE\src\sample_profile
  group lib
    ../../../../../lib/: BLE_CONTROLLER_lib.a BLE_HOST_lib.a BLE_PROFILE_ANP_lib.a BLE_PROFILE_BLP_lib.a BLE_PROFILE_CPP_lib.a BLE_PROFILE_CSP_lib.a BLE_PROFILE_FMP_lib.a BLE_PROFILE_GLP_lib.a BLE_PROFILE_HGP_lib.a BLE_PROFILE_HRP_lib.a BLE_PROFILE_HTP_lib.a BLE_PROFILE_LNP_lib.a BLE_PROFILE_PAP_lib.a BLE_PROFILE_PXP_lib.a BLE_PROFILE_RSP_lib.a BLE_PROFILE_SCP_lib.a BLE_PROFILE_TIP_lib.a BLE_PROFILES_COMMON_lib.a BLE_rBLE_lib.a
  group rBLE/sample
    ../../../../../../rBLE/src/sample_app/: beacon_app.c Console.c menu_sel.c rble_fw_up_receiver_app.c rble_sample_app.c rble_sample_app_anp.c rble_sample_app_blp.c rble_sample_app_cpp.c rble_sample_app_cscp.c rble_sample_app_custom.c rble_sample_app_fmp.c rble_sample_app_fwup.c rble_sample_app_gap_sm_gatt.c rble_sample_app_glp.c rble_sample_app_hogp.c rble_sample_app_hrp.c rble_sample_app_htp.c rble_sample_app_lnp.c rble_sample_app_pasp.c rble_sample_app_pxp.c rble_sample_app_rscp.c rble_sample_app_scpp.c rble_sample_app_tip.c rble_sample_app_vendor.c
  group rBLE/sample_profile/fwup
    ../../../../../../rBLE/src/sample_profile/fwup/: fwupr.c
  group rBLE/sample_profile/scp
    ../../../../../../rBLE/src/sample_profile/scp/: scpc.c scps.c
  group renesas/arch
    ../../../../../src/arch/rl78/: arch_main.c fw_update_count0.c fw_update_count1.c ke_conf.c main.c prf_config.c prf_config_host.c rble_core_config.c rble_modem_config.c rwble_mem.c
  group renesas/driver/codeflash
    ../../../../../src/driver/codeflash/: codeflash.c
  group renesas/driver/codeflash/lib
    ../../../../../src/driver/codeflash/iar_v2/: fsl.a
  group renesas/driver/dataflash
    ../../../../../src/driver/dataflash/: dataflash.c eel_descriptor_t02.c fdl_descriptor_t02.c
  group renesas/driver/dataflash/lib
    ../../../../../src/driver/dataflash/iar_v2/: eel.a fdl.a
  group renesas/driver/DTM2Wire
    ../../../../../src/driver/DTM2Wire/: DTM2Wire.c
  group renesas/driver/led
    ../../../../../src/driver/led/: led.c
  group renesas/driver/peak
    ../../../../../src/driver/peak/: peak_isr.c
  group renesas/driver/plf
    ../../../../../src/driver/plf/: plf.c
  group renesas/driver/push_sw
    ../../../../../src/driver/push_sw/: push_sw.c
  group renesas/driver/uart
    ../../../../../src/driver/uart/: uart.c
  group renesas/driver/wakeup
    ../../../../../src/driver/wakeup/: wakeup.c
